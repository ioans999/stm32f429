# Keil uVision project project-PLC.uvproj, settings and files
target PLC (ARM-ADS)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: project-PLC
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f4xx.c
  group MDK-ARM
    ./: startup_stm32f4xx.s startup_stm32f427x.s
  group LwIP
    ../Utilities/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Utilities/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../Utilities/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../Utilities/lwip-1.4.1/src/netif/: etharp.c
    ../Utilities/lwip-1.4.1/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
