# Keil uVision project project-PLC.uvproj, settings and files
target PLC (ARM-ADS)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: project-PLC +hex
  c flags: Optim=4 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427X,__FPU_USED=1,__FPU_PRESENT=1
  c include: ..\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4x7_ETH_Driver\inc;..\Utilities\lwip-1.4.1\src\include;..\Utilities\lwip-1.4.1\src\include\lwip;..\Utilities\lwip-1.4.1\src\include\netif;..\Utilities\lwip-1.4.1\src\include\ipv4;..\Utilities\lwip-1.4.1\port\STM32F4x7;..\Utilities\lwip-1.4.1\port\STM32F4x7\FreeRTOS;..\Utilities\FreeRTOSV7.3.0\portable\RVDS\ARM_CM3;..\Utilities\FreeRTOSV7.3.0\include;..\Utilities\FatFs_vR0.09b
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f4xx.c
  group MDK-ARM
    ./: startup_stm32f4xx.s startup_stm32f427x.s
  group LwIP
    ../Utilities/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Utilities/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../Utilities/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../Utilities/lwip-1.4.1/src/netif/: etharp.c
    ../Utilities/lwip-1.4.1/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_rtc.c stm32f4xx_tim.c
  group STM32F4x7_ETH_Driver
    ../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group FreeRTOS
    ../Utilities/FreeRTOSV7.3.0/portable/RVDS/ARM_CM3/: port.c
    ../Utilities/FreeRTOSV7.3.0/: tasks.c croutine.c list.c queue.c
    ../Utilities/FreeRTOSV7.3.0/portable/MemMang/: heap_4.c
  group FatFs
    ../Utilities/FatFs_vR0.09b/: sdio_sd.c ff.c fattime.c diskio.c
  group Src
    ../: main.c
    ../src/: stm32f4xx_it.c stm32f4x7_eth_bsp.c netconf.c sys_config.c algbloc.c udp_server.c modbus.c utilities.c
    ../src/FTP_Server/: ftp_server.c
    ../src/Usart/: usart1.c usart2.c usart3.c usart4.c
